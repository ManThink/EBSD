# IAR project ST11TA.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L190FCUA HDSC HC32L190FCUA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING1
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\src\Hook\ST11TAHook; ..\..\src\Sensor\LIS2DH12; ..\..\src\Sensor\DS18B20; ..\..\src\Driver\I2C
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: T&H.hex
  ILINK.IlinkOutputFile: T&H.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: ..\..\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\LWS429LibV120.a; ..\..\lib\EBLibV110.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../: MT_ColorBrickV1.0.icf
  group DS18B20
    ../../src/Sensor/DS18B20/: DS18B20.c DS18B20.h
  group I2C
    ../../src/Driver/I2C/: EB_I2C.c EB_I2C.h
  group LIS2DH12
    ../../src/Sensor/LIS2DH12/: LIS2DH12.c LIS2DH12.h lis2dh12_reg.c lis2dh12_reg.h
  group ST11TAHook
    ../../src/Hook/ST11TAHook/: ST11TAHook.c ST11TAHook.h ST11TAType.h
