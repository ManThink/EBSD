# IAR project BSE01A.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L190FCUA HDSC HC32L190FCUA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING1
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\src\Hook\BSE01A\Hook; ..\..\src\Sensor\LIS2DH12; ..\..\src\Sensor\DS18B20; ..\..\src\Driver\I2C
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: T&H.hex
  ILINK.IlinkOutputFile: BSE01A.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: ..\..\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\LWS429LibV120.a; ..\..\lib\EBLibV110.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../src/Hook/BSE01AHook/: BSE01AType.h
  group BSE01AHook
    ../../src/Hook/BSE01AHook/: BSE01AHook.c
