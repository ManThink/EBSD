# IAR project Backup (2) of BSE01A.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L190FCUA HDSC HC32L190FCUA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING; _DEBUGING
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\project\BSE01A\BSE01AHook; ..\..\project\BSE01A
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: T&H.hex
  ILINK.IlinkOutputFile: T&H.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: E:\SVN2.0\RDSoftware\Module\EBSD\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: E:\SVN2.0\RDSoftware\Module\EBSD\lib\EBLib.a; E:\SVN2.0\RDSoftware\Module\EBSD\lib\LWS429Lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../src/Hook/BSE01AHook/: BSE01AType.h
  group BSE01AHook
    ../../src/Hook/BSE01AHook/: BSE01AHook.c
