# IAR project Backup of BSE01B.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L190FCUA HDSC HC32L190FCUA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\project\BSE01B\BSE01BHook; ..\..\project\BSE01B; ..\..\src\Sensor\DS18B20
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: T&H.hex
  ILINK.IlinkOutputFile: T&H.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: ..\..\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: E:\SVN2.0\RDSoftware\Module\LWS17\project\LWS429lib\output\debug\Exe\LWS429Lib.a; E:\SVN2.0\RDSoftware\Module\EdgeBus\project\EBLib\Debug\Exe\EBLib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group (top)
    ./: BSE01BType.h
  group BSE01BHook
    ../../src/Hook/BSE01BHook/: BSE01BHook.c
  group DS18B20
    ../../src/Sensor/DS18B20/: DS18B20.c DS18B20.h
