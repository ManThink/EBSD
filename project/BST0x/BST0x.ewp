# IAR project BST0x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L190FCUA HDSC HC32L190FCUA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING1
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\src\Hook\BST0xHook; ..\..\src\Sensor\LIS2DH12; ..\..\src\Sensor\DS18B20; ..\..\src\Sensor\GPS; ..\..\src\Driver\I2C
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPS.hex
  ILINK.IlinkOutputFile: BST0x.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: ..\..\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\LWS429LibV120.a; ..\..\lib\EBLibV110.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BST0xHook
    ../../src/Hook/BST0xHook/: BST0xHook.c
  group GPS
    ../../src/Sensor/GPS/: GPS.c
