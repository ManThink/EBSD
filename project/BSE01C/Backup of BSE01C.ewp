# IAR project Backup of BSE01C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32L190FCUA HDSC HC32L190FCUA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\project\BSE01C\BSE01CHook; ..\..\project\BSE01C; ..\..\src\Sensor\SHT20; ..\..\src\Driver\I2C; E:\SVN2.0\RDSoftware\Module\EBSD\src\Hook\BSE01CHook
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: T&H.hex
  ILINK.IlinkOutputFile: T&H.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: ..\..\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: E:\SVN2.0\RDSoftware\Module\LWS17\project\LWS429lib\output\debug\Exe\LWS429Lib.a; E:\SVN2.0\RDSoftware\Module\EdgeBus\project\EBLib\Debug\Exe\EBLib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group BSE01CHook
    ../../src/Hook/BSE01CHook/: BSE01CHook.c
  group I2C
    ../../src/Driver/I2C/: EB_I2C.c EB_I2C.h
  group SHT20
    ../../src/Sensor/SHT20/: SHT20.c SHT20.h
