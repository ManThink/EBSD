# IAR project BSE01C.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _MPOS_RAMLOAD_LIB; _APP_DEBUGING1
  ICCARM.CCIncludePath2: ..\..\include; ..\..\include\APP; ..\..\src\Hook\BSE01CHook; ..\..\src\Sensor\LIS2DH12; ..\..\src\Sensor\DS18B20; ..\..\src\Sensor\SHT20; ..\..\src\Driver\I2C
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: T&H.hex
  ILINK.IlinkOutputFile: BSE01C.out
  ILINK.IlinkKeepSymbols: mpos_main
  ILINK.IlinkIcfFile: ..\..\MT_ColorBrickV1.0.icf
  ILINK.IlinkAdditionalLibs: ..\..\lib\LWS429LibV120.a; ..\..\lib\EBLibV110.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSE01CHook
    ../../src/Hook/BSE01CHook/: BSE01CHook.c
  group I2C
    ../../src/Driver/I2C/: EB_I2C.c EB_I2C.h
  group SHT20
    ../../src/Sensor/SHT20/: SHT20.c SHT20.h
